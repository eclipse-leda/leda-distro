#RDEPENDS:packagegroup-meta-oe-extended:remove = "haveged"
#packagegroup-meta-oe-extended:remove = "haveged"
LICENSE = "Apache-2.0"
#SKIP_RECIPE[haveged] = "Incopatible license GPL-3.0-only"