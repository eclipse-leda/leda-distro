#RRECOMMENDS:${PN}-sshd:remove:tegra210 = "haveged"
#RRECOMMENDS:${PN}-sshd:append:tegra210 = " rng-tools"
#PACKAGE_ARCH:tegra210 = "${TEGRA_PKGARCH}"
