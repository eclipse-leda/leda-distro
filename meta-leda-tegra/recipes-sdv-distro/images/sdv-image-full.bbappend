IMAGE_BOOT_FILES:jetson-nano-2gb-devkit = "Image u-boot.bin tegra210-p3448-0003-p3542-0000-jetson-nano-2gb-devkit.dtb u-boot-jetson-nano-2gb-devkit.bin"
INCOMPATIBLE_LICENSE:jetson-nano-2gb-devkit = ""

IMAGE_BOOT_FILES:jetson-nano-devkit = "Image u-boot.bin tegra210-p3448-0000-p3449-0000-a02.dtb \
		      tegra210-p3448-0000-p3449-0000-b00.dtb u-boot-jetson-nano-devkit.bin"
INCOMPATIBLE_LICENSE:jetson-nano-devkit = ""